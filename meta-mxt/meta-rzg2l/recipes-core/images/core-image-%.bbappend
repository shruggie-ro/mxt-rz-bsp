IMAGE_INSTALL:append = " \
	da16600 \
"
