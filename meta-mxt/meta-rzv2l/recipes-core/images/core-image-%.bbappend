IMAGE_INSTALL:append = " \
	custom-configs \
	ustreamer \
"
